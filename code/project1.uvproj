# Keil uVision project project1.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F5701 SONiX
  cpu: IRAM(0-0xFF) IROM(0-0x0FF5) CLOCK(32000000) DPC
  output: project1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: OPTIONS_SN8F5701.A51 main.c SN8F5701.H
